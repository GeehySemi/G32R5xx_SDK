# IAR project cpu1.ewp, settings and files
configuration G32R501 (ARM, debug)
  General.OGChipSelectEditMenu: G32R501DxY Geehy G32R501DxYx7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: __G32R501XX__; __ARM_ARCH_8_1M_MAIN___; __ARM_TARGET_COPROC; __G32R501__; __CORE_CPU0__; G32R501_EVAL; __ZIDIAN_FCAU__
  ICCARM.IExtraOptions: --cdecp=0
  ICCARM.CCIncludePath2: ..\..\; ..\..\include; ..\..\..\common; ..\..\..\..\..\Source\include; ..\..\..\..\..\Source\portable\IAR\ARM_CM52_NTZ\non_secure; ..\..\..\..\..\..\..\device_support\common\CMSIS\Core\Include; ..\..\..\..\..\..\..\device_support\g32r501\common\device\Geehy; ..\..\..\..\..\..\..\device_support\g32r501\common\device\Geehy\system_eval\include; ..\..\..\..\..\..\..\device_support\common\device\Geehy\system_eval\include; ..\..\..\..\..\..\..\device_support\g32r501\common\include; ..\..\..\..\..\..\..\device_support\g32r501\headers\include; ..\..\..\..\..\..\..\driverlib\g32r501\boards_support\eval\include; ..\..\..\..\..\..\..\driverlib\g32r501\driverlib; ..\..\..\..\..\..\..\driverlib\g32r501\driverlib\inc; ..\..\..\..\..\..\..\libraries\dsp\FPU\g32r501\include; ..\..\..\..\..\..\..\libraries\dsp\VCU\g32r501\include; ..\..\..\..\..\..\..\libraries\dsp\Fixed_Point\g32r501\include; ..\..\..\..\..\..\..\libraries\math\FPUfastRTS\g32r501\include; ..\..\..\..\..\..\..\libraries\math\Fix32math\g32r501\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: ..\..; ..\..\..\..\..\Source\include; ..\..\..\..\..\Source\portable\IAR\ARM_CM52_NTZ\non_secure
  OBJCOPY.OOCOutputFile: ..\..\..\cpu0\source\cpu1_image.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: g32r501dxyx7_cpu1_cbus_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group device
    ../../../../../../../device_support/g32r501/common/device/Geehy/startup/arm/: startup_g32r501.c
    ../../../../../../../device_support/g32r501/common/device/Geehy/system_eval/: system_g32r501.c
    ../../../../../../../device_support/g32r501/common/source/: device.c
  group driverlib
    ../../../../../../../driverlib/g32r501/driverlib/: adc.c as.c can.c cap.c comp.c cortex.c dac.c dbgmcu.c dccomp.c dma.c exti.c flash.c gpio.c hrcap.c hrpwm.c i2c.c interrupt.c ipc.c lin.c pmbus.c pwm.c qep.c sdf.c spi.c sysctl.c tmr.c uart.c version.c xbar.c
  group user
    ../../source/: main.c board.c tasks_led.c tasks_worker.c
  group FreeRTOS
    ../../../../../Source/: tasks.c list.c queue.c timers.c
    ../../../../../Source/portable/IAR/ARM_CM52_NTZ/non_secure/: port.c portasm.s
    ../../../../../Source/portable/MemMang/: heap_4.c
