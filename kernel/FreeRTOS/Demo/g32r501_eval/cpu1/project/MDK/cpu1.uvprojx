# Keil uVision project cpu1.uvprojx, settings and files
target G32R501 (6220000::V6.22::ARMCLANG)
  device: G32R501DVY:CPU1 Geehy
  pack: Geehy.G32R5xx_DFP.1.0.0
  cpu: IRAM(0x00000000,0x00002000) IRAM2(0x20000000,0x00002000) IRAM3(0x20100000,0x00002000) IRAM4(0x20200000,0x00002000) IRAM5(0x20300000,0x00008000) IROM(0x08000000,0x000A0000) CPUTYPE("Cortex-M52") FPU3(DFPU) DSP MVE(FP) CDECP(0x01) PACBTI CLOCK(12000000) ESEL ELITTLE
  output: g32r501_eval_cpu1 +hex
  AfterMake: fromelf --bin --output "..\..\..\cpu0\source\cpu1_image.bin" "#L"
  AfterMake: ..\..\..\..\..\..\..\utilities\keil_dbg_tool\keil_dbg_tool -r -a "#L" -d .\r501_dbg.ini
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: __G32R501XX__,__ARM_ARCH_8_1M_MAIN___,__ARM_TARGET_COPROC,__G32R501__,__CORE_CPU0__,G32R501_EVAL,__ZIDIAN_FCAU__
  c misc: -mcpu=cortex-m52+cdecp0
  c include: ..\..\;..\..\include;..\..\..\common;..\..\..\..\..\Source\include;..\..\..\..\..\Source\portable\GCC\ARM_CM52_NTZ\non_secure;..\..\..\..\..\..\..\device_support\common\CMSIS\Core\Include;..\..\..\..\..\..\..\device_support\g32r501\common\device\Geehy;..\..\..\..\..\..\..\device_support\g32r501\common\device\Geehy\system_eval\include;..\..\..\..\..\..\..\device_support\common\device\Geehy\system_eval\include;..\..\..\..\..\..\..\device_support\g32r501\common\include;..\..\..\..\..\..\..\device_support\g32r501\headers\include;..\..\..\..\..\..\..\driverlib\g32r501\boards_support\eval\include;..\..\..\..\..\..\..\driverlib\g32r501\driverlib;..\..\..\..\..\..\..\driverlib\g32r501\driverlib\inc;..\..\..\..\..\..\..\libraries\dsp\FPU\g32r501\include;..\..\..\..\..\..\..\libraries\dsp\VCU\g32r501\include;..\..\..\..\..\..\..\libraries\dsp\Fixed_Point\g32r501\include;..\..\..\..\..\..\..\libraries\math\FPUfastRTS\g32r501\include;..\..\..\..\..\..\..\libraries\math\Fix32math\g32r501\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xa0000
  memory RVCT9: RAM 0x0 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: .\g32r501dxy_cpu1_cbus_flash.sct
  group device
    ../../../../../../../device_support/g32r501/common/device/Geehy/startup/arm/: startup_g32r501.c
    ../../../../../../../device_support/g32r501/common/device/Geehy/system_eval/: system_g32r501.c
    ../../../../../../../device_support/g32r501/common/source/: device.c
  group driverlib
    ../../../../../../../driverlib/g32r501/driverlib/: adc.c as.c can.c cap.c comp.c cortex.c dac.c dbgmcu.c dccomp.c dma.c exti.c flash.c gpio.c hrcap.c hrpwm.c i2c.c interrupt.c ipc.c lin.c pmbus.c pwm.c qep.c sdf.c spi.c sysctl.c tmr.c uart.c version.c xbar.c
  group user
    ../../source/: main.c board.c tasks_led.c tasks_worker.c
  group FreeRTOS
    ../../../../../Source/: tasks.c list.c queue.c timers.c
    ../../../../../Source/portable/GCC/ARM_CM52_NTZ/non_secure/: port.c portasm.c
    ../../../../../Source/portable/MemMang/: heap_4.c
