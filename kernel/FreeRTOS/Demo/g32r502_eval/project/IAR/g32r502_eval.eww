<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\g32r502_eval.ewp</path>
    </project>
    <batchBuild />
</workspace>
