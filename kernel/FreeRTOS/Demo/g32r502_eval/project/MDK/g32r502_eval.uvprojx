# Keil uVision project g32r502_eval.uvprojx, settings and files
target G32R502 (6240000::V6.24::ARMCLANG)
  device: G32R502MC Geehy
  pack: Geehy.G32R5xx_DFP.1.0.3
  cpu: IRAM(0x00000000,0x00004000) IRAM2(0x20000000,0x00006000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M52") FPU3(SFPU) DSP MVE(INT) CDECP(0x01) PACBTI CLOCK(12000000) ESEL ELITTLE
  output: g32r502_eval +hex
  AfterMake: ..\..\..\..\..\..\utilities\keil_dbg_tool\keil_dbg_tool -r -a "#L" -d .\r502_dbg.ini
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: __G32R502XX__,__ARM_ARCH_8_1M_MAIN___,__ARM_TARGET_COPROC,__G32R502__,G32R502_EVAL
  c misc: -mcpu=cortex-m52+nomve.fp+nofp.dp+cdecp0
  c include: ..\..\;..\..\include;..\..\..\..\Source\include;..\..\..\..\Source\portable\GCC\ARM_CM52_NTZ\non_secure;..\..\..\..\..\..\device_support\common\CMSIS\Core\Include;..\..\..\..\..\..\device_support\g32r502\common\device\Geehy;..\..\..\..\..\..\device_support\g32r502\common\device\Geehy\system_eval\include;..\..\..\..\..\..\device_support\common\device\Geehy\system_eval\include;..\..\..\..\..\..\device_support\g32r502\common\include;..\..\..\..\..\..\device_support\g32r502\headers\include;..\..\..\..\..\..\boards_support\eval\include;..\..\..\..\..\..\driverlib\g32r502\driverlib;..\..\..\..\..\..\driverlib\g32r502\driverlib\inc;..\..\..\..\..\..\libraries\dsp\FPU\g32r502\include;..\..\..\..\..\..\libraries\dsp\VCU\g32r502\include;..\..\..\..\..\..\libraries\dsp\Fixed_Point\g32r502\include;..\..\..\..\..\..\libraries\math\FPUfastRTS\g32r502\include;..\..\..\..\..\..\libraries\math\Fix32math\g32r502\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x0 size 0x4000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: .\g32r502xc_cbus_flash.sct
  group device
    ../../../../../../device_support/g32r502/common/device/Geehy/system_eval/: system_g32r502.c
    ../../../../../../device_support/g32r502/common/device/Geehy/startup/arm/: startup_g32r502.c
    ../../../../../../device_support/g32r502/common/source/: device.c
  group driverlib
    ../../../../../../driverlib/g32r502/driverlib/: adc.c as.c can.c cap.c comp.c cortex.c dac.c dbgmcu.c dccomp.c dma.c exti.c flash.c gpio.c hrpwm.c i2c.c interrupt.c lin.c pmbus.c pwm.c qep.c spi.c sysctl.c tmr.c uart.c version.c xbar.c
  group FreeRTOS/Core
    ../../../../Source/: tasks.c list.c queue.c timers.c
  group FreeRTOS/Port
    ../../../../Source/portable/GCC/ARM_CM52_NTZ/non_secure/: port.c portasm.c
  group FreeRTOS/Heap
    ../../../../Source/portable/MemMang/: heap_4.c
  group user
    ../../: main.c board.c tasks_led.c tasks_uart.c
