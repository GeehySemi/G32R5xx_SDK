<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\pwm_ex13_up_aq.ewp</path>
    </project>
    <batchBuild />
</workspace>
