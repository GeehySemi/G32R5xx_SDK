<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\pwm_ex3_synchronization.ewp</path>
    </project>
    <batchBuild />
</workspace>
