<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\pwm_ex5_digital_compare_event_filter.ewp</path>
    </project>
    <batchBuild />
</workspace>
