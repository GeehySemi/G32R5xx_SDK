<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\dma_ex2_sram_transfer.ewp</path>
    </project>
    <batchBuild />
</workspace>
