<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\spi_ex4_external_loopback_fifo_interrupts.ewp</path>
    </project>
    <batchBuild />
</workspace>
