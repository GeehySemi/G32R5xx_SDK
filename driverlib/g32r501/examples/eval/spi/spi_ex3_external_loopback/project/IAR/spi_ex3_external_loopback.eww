<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\spi_ex3_external_loopback.ewp</path>
    </project>
    <batchBuild />
</workspace>
