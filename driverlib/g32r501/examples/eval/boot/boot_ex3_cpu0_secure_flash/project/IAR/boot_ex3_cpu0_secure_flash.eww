<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\boot_ex3_cpu0_secure_flash.ewp</path>
    </project>
    <batchBuild />
</workspace>
