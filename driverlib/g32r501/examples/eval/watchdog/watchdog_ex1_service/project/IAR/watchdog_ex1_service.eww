<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\watchdog_ex1_service.ewp</path>
    </project>
    <batchBuild />
</workspace>
