<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\flashapi_ex6_bank_mode_switch.ewp</path>
    </project>
    <batchBuild />
</workspace>
