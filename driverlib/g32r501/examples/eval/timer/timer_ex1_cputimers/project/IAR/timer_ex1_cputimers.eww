<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\timer_ex1_cputimers.ewp</path>
    </project>
    <batchBuild />
</workspace>
