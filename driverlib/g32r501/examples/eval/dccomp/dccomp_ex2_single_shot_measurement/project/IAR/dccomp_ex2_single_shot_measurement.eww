<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\dccomp_ex2_single_shot_measurement.ewp</path>
    </project>
    <batchBuild />
</workspace>
