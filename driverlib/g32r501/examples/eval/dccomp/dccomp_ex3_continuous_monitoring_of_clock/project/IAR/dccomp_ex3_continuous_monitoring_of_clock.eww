<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\dccomp_ex3_continuous_monitoring_of_clock.ewp</path>
    </project>
    <batchBuild />
</workspace>
