<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\dccomp_ex1_single_shot_verification.ewp</path>
    </project>
    <batchBuild />
</workspace>
