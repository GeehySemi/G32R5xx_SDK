<?xml version="1.0" encoding="UTF-8"?>

<workspace>
  <project>
    <path>$WS_DIR$\lpm_ex6_haltwake_gpio_watchdog.ewp</path>
  </project>
  <batchBuild/>
</workspace>
