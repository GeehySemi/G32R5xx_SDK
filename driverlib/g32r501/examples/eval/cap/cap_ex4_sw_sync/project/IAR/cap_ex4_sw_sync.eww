<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\cap_ex4_sw_sync.ewp</path>
    </project>
    <batchBuild />
</workspace>
