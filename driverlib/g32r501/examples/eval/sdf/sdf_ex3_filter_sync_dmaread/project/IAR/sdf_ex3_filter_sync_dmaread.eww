<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\sdf_ex3_filter_sync_dmaread.ewp</path>
    </project>
    <batchBuild />
</workspace>
