<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\sdf_ex5_filter_sync_fifo_cpuread.ewp</path>
    </project>
    <batchBuild />
</workspace>
