<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\sdf_ex1_filter_sync_cpuread.ewp</path>
    </project>
    <batchBuild />
</workspace>
