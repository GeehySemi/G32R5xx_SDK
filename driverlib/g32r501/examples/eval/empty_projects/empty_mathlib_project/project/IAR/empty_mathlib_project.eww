<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\empty_mathlib_project.ewp</path>
    </project>
    <batchBuild />
</workspace>
