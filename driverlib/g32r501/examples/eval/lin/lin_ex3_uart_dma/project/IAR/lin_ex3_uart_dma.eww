<?xml version="1.0" encoding="UTF-8"?>

<workspace>
  <project>
    <path>$WS_DIR$\lin_ex3_uart_dma.ewp</path>
  </project>
  <batchBuild/>
</workspace>
