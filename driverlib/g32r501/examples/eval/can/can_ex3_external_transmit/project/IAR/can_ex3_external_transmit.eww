<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\can_ex3_external_transmit.ewp</path>
    </project>
    <batchBuild />
</workspace>
