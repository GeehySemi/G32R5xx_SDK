<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\can_ex6_error_generation.ewp</path>
    </project>
    <batchBuild />
</workspace>
