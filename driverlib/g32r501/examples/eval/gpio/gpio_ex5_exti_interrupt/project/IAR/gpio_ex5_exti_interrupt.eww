<?xml version="1.0" encoding="UTF-8"?>

<workspace>
  <project>
    <path>$WS_DIR$\gpio_ex5_exti_interrupt.ewp</path>
  </project>
  <batchBuild/>
</workspace>
