<?xml version="1.0" encoding="UTF-8"?>

<workspace>
  <project>
    <path>$WS_DIR$\hrcap_ex1_capture.ewp</path>
  </project>
  <batchBuild/>
</workspace>
