<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\qep_ex5_speed_dir_motor.ewp</path>
    </project>
    <batchBuild />
</workspace>
