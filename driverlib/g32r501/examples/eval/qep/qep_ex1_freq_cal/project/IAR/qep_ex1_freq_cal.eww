<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\qep_ex1_freq_cal.ewp</path>
    </project>
    <batchBuild />
</workspace>
