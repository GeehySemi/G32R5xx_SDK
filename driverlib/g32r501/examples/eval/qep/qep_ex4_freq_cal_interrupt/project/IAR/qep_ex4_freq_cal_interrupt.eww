<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\qep_ex4_freq_cal_interrupt.ewp</path>
    </project>
    <batchBuild />
</workspace>
