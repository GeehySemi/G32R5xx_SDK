<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\zidian_ex1_math.ewp</path>
    </project>
    <batchBuild />
</workspace>
