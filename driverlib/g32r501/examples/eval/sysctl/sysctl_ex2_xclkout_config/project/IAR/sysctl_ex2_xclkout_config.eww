<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\sysctl_ex2_xclkout_config.ewp</path>
    </project>
    <batchBuild />
</workspace>
