<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\sysctl_ex1_missing_clock_detection.ewp</path>
    </project>
    <batchBuild />
</workspace>
