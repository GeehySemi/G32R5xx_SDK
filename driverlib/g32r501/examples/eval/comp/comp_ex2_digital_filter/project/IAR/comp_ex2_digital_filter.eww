<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\comp_ex2_digital_filter.ewp</path>
    </project>
    <batchBuild />
</workspace>
