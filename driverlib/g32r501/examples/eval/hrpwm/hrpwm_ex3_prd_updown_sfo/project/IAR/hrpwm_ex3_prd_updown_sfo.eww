<?xml version="1.0" encoding="UTF-8"?>

<workspace>
  <project>
    <path>$WS_DIR$\hrpwm_ex3_prd_updown_sfo.ewp</path>
  </project>
  <batchBuild/>
</workspace>
