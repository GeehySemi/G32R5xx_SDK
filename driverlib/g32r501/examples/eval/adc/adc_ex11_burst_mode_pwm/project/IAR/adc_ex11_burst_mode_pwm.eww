<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\adc_ex11_burst_mode_pwm.ewp</path>
    </project>
    <batchBuild />
</workspace>
