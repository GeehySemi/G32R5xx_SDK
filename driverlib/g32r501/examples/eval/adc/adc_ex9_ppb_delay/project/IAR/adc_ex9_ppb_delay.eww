<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\adc_ex9_ppb_delay.ewp</path>
    </project>
    <batchBuild />
</workspace>
