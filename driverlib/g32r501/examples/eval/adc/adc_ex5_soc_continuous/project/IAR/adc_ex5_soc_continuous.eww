<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\adc_ex5_soc_continuous.ewp</path>
    </project>
    <batchBuild />
</workspace>
