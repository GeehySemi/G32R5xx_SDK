<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\adc_ex15_open_shorts_detection.ewp</path>
    </project>
    <batchBuild />
</workspace>
