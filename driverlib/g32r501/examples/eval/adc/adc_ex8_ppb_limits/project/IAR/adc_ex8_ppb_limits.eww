<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\adc_ex8_ppb_limits.ewp</path>
    </project>
    <batchBuild />
</workspace>
