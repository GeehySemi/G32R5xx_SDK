<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\dccomp_ex4_clock_fail_detect.ewp</path>
    </project>
    <batchBuild />
</workspace>
