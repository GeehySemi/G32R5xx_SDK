<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\lin_ex4_loopback_polling.ewp</path>
    </project>
    <batchBuild />
</workspace>
