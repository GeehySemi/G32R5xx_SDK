<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\lin_ex1_loopback_interrupts.ewp</path>
    </project>
    <batchBuild />
</workspace>
