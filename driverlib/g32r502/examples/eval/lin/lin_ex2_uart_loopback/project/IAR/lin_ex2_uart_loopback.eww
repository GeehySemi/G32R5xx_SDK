<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\lin_ex2_uart_loopback.ewp</path>
    </project>
    <batchBuild />
</workspace>
