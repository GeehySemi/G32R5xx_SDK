<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\comp_ex1_asynch.ewp</path>
    </project>
    <batchBuild />
</workspace>
