<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\can_ex7_loopback_tx_rx_remote_frame.ewp</path>
    </project>
    <batchBuild />
</workspace>
