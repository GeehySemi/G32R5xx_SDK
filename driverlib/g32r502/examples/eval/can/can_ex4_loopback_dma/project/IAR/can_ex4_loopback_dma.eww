<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\can_ex4_loopback_dma.ewp</path>
    </project>
    <batchBuild />
</workspace>
