<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\interrupt_ex1_external.ewp</path>
    </project>
    <batchBuild />
</workspace>
