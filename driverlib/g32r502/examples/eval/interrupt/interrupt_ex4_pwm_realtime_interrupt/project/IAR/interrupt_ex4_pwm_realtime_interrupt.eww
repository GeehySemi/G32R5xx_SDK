<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\interrupt_ex4_pwm_realtime_interrupt.ewp</path>
    </project>
    <batchBuild />
</workspace>
