<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\cap_ex3_apwm_phase_shift.ewp</path>
    </project>
    <batchBuild />
</workspace>
