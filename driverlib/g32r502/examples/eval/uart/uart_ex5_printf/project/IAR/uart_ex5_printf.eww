<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\uart_ex5_printf.ewp</path>
    </project>
    <batchBuild />
</workspace>
