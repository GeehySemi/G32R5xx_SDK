<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\hrpwm_ex2_slider.ewp</path>
    </project>
    <batchBuild />
</workspace>
