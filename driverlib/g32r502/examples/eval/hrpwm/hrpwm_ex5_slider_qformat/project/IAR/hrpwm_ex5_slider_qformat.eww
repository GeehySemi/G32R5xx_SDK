<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\hrpwm_ex5_slider_qformat.ewp</path>
    </project>
    <batchBuild />
</workspace>
