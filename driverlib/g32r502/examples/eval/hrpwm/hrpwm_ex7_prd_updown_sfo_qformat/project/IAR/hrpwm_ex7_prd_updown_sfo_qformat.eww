<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\hrpwm_ex7_prd_updown_sfo_qformat.ewp</path>
    </project>
    <batchBuild />
</workspace>
