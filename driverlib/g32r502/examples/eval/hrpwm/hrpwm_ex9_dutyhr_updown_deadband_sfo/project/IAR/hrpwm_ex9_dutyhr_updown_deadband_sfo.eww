<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\hrpwm_ex9_dutyhr_updown_deadband_sfo.ewp</path>
    </project>
    <batchBuild />
</workspace>
