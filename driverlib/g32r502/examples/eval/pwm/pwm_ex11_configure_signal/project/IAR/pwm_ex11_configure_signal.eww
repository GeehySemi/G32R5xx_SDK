<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\pwm_ex11_configure_signal.ewp</path>
    </project>
    <batchBuild />
</workspace>
