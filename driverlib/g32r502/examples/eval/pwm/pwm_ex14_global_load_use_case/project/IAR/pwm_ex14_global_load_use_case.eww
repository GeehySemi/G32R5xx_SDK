<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\pwm_ex14_global_load_use_case.ewp</path>
    </project>
    <batchBuild />
</workspace>
