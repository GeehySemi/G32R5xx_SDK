<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\flashapi_ex1_program_autoecc.ewp</path>
    </project>
    <batchBuild />
</workspace>
