<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\led_ex1_blinky.ewp</path>
    </project>
    <batchBuild />
</workspace>
