# IAR project empty_mathlib_project.ewp, settings and files
configuration G32R502 (ARM, debug)
  General.OGChipSelectEditMenu: G32R502xC Geehy G32R502xCx7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 6
  ICCARM.CCDefines: __G32R502XX__; __ARM_ARCH_8_1M_MAIN___; __ARM_TARGET_COPROC; __G32R502__; G32R502_EVAL
  ICCARM.CCIncludePath2: ..\..\include; ..\..\..\..\..\..\..\..\device_support\common\CMSIS\Core\Include; ..\..\..\..\..\..\..\..\device_support\g32r502\common\device\Geehy; ..\..\..\..\..\..\..\..\device_support\g32r502\common\device\Geehy\system_eval\include; ..\..\..\..\..\..\..\..\device_support\common\device\Geehy\system_eval\include; ..\..\..\..\..\..\..\..\device_support\g32r502\common\include; ..\..\..\..\..\..\..\..\device_support\g32r502\headers\include; ..\..\..\..\..\..\boards_support\eval\include; ..\..\..\..\..\..\driverlib; ..\..\..\..\..\..\driverlib\inc; ..\..\..\..\..\..\..\..\libraries\dsp\FPU\g32r502\include; ..\..\..\..\..\..\..\..\libraries\dsp\VCU\g32r502\include; ..\..\..\..\..\..\..\..\libraries\dsp\Fixed_Point\g32r502\include; ..\..\..\..\..\..\..\..\libraries\math\FPUfastRTS\g32r502\include; ..\..\..\..\..\..\..\..\libraries\math\Fix32math\g32r502\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: g32r502xcx7_cbus_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\..\..\libraries\dsp\Fixed_Point\g32r502\lib\g32r502_FixedPoint_ICC.a; ..\..\..\..\..\..\..\..\libraries\dsp\FPU\g32r502\lib\g32r502_FPU_ICC.a; ..\..\..\..\..\..\..\..\libraries\dsp\VCU\g32r502\lib\g32r502_VCU_ICC.a; ..\..\..\..\..\..\..\..\libraries\math\FPUfastRTS\g32r502\lib\g32r502_FPUfastRTS_ICC.a; ..\..\..\..\..\..\..\..\libraries\math\Fix32math\g32r502\lib\g32r502_Fix32math_ICC.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group device
    ../../../../../../../../device_support/g32r502/common/device/Geehy/system_eval/: system_g32r502.c
    ../../../../../../../../device_support/g32r502/common/device/Geehy/startup/arm/: startup_g32r502.c
    ../../../../../../../../device_support/g32r502/common/source/: device.c
  group driverlib
    ../../../../../../driverlib/: adc.c as.c can.c cap.c comp.c cortex.c dac.c dbgmcu.c dccomp.c dma.c exti.c flash.c gpio.c hrpwm.c i2c.c interrupt.c pwm.c qep.c spi.c sysctl.c tmr.c uart.c version.c xbar.c
  group user
    ../../source/: main.c empty_mathlib_main.c board.c
