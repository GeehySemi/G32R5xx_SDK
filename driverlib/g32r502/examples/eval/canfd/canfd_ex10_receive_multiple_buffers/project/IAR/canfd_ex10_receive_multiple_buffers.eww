<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\canfd_ex10_receive_multiple_buffers.ewp</path>
    </project>
    <batchBuild />
</workspace>
