<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\canfd_ex15_timestamp.ewp</path>
    </project>
    <batchBuild />
</workspace>
