<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\canfd_ex12_receive_priority.ewp</path>
    </project>
    <batchBuild />
</workspace>
