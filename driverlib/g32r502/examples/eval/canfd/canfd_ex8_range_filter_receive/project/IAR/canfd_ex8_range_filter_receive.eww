<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\canfd_ex8_range_filter_receive.ewp</path>
    </project>
    <batchBuild />
</workspace>
