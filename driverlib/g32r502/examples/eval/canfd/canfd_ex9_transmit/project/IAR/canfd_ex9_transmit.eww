<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\canfd_ex9_transmit.ewp</path>
    </project>
    <batchBuild />
</workspace>
