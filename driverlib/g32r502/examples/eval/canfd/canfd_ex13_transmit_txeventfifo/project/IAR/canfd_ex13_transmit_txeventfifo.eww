<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\canfd_ex13_transmit_txeventfifo.ewp</path>
    </project>
    <batchBuild />
</workspace>
