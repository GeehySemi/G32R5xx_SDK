<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\canfd_ex5_mask_filter_receive.ewp</path>
    </project>
    <batchBuild />
</workspace>
