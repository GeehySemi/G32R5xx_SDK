<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\boot_ex5_boot_status.ewp</path>
    </project>
    <batchBuild />
</workspace>
