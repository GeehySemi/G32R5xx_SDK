# IAR project boot_ex2_customBootConfig.ewp, settings and files
configuration ZERO_BMSPS (ARM, debug)
  General.OGChipSelectEditMenu: G32R502xC Geehy G32R502xCx7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 6
  ICCARM.CCDefines: ZERO_BMSPS; __G32R502XX__; __ARM_ARCH_8_1M_MAIN___; __ARM_TARGET_COPROC; __G32R502__; G32R502_EVAL
  ICCARM.CCIncludePath2: ..\..\include; ..\..\..\..\..\..\..\..\device_support\common\CMSIS\Core\Include; ..\..\..\..\..\..\..\..\device_support\g32r502\common\device\Geehy; ..\..\..\..\..\..\..\..\device_support\g32r502\common\device\Geehy\system_eval\include; ..\..\..\..\..\..\..\..\device_support\common\device\Geehy\system_eval\include; ..\..\..\..\..\..\..\..\device_support\g32r502\common\include; ..\..\..\..\..\..\..\..\device_support\g32r502\headers\include; ..\..\..\..\..\..\boards_support\eval\include; ..\..\..\..\..\..\driverlib; ..\..\..\..\..\..\driverlib\inc; ..\..\..\..\..\..\..\..\libraries\dsp\FPU\g32r502\include; ..\..\..\..\..\..\..\..\libraries\dsp\VCU\g32r502\include; ..\..\..\..\..\..\..\..\libraries\dsp\Fixed_Point\g32r502\include; ..\..\..\..\..\..\..\..\libraries\math\FPUfastRTS\g32r502\include; ..\..\..\..\..\..\..\..\libraries\math\Fix32math\g32r502\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: g32r502xcx7_cbus_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration ONE_BMSP (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: ONE_BMSP; __G32R502XX__; __ARM_ARCH_8_1M_MAIN___; __ARM_TARGET_COPROC; __G32R502__
configuration THREE_BMSPS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: THREE_BMSPS; __G32R502XX__; __ARM_ARCH_8_1M_MAIN___; __ARM_TARGET_COPROC; __G32R502__
  group device
    ../../../../../../../../device_support/g32r502/common/device/Geehy/system_eval/: system_g32r502.c
    ../../../../../../../../device_support/g32r502/common/device/Geehy/startup/arm/: startup_g32r502.c
    ../../../../../../../../device_support/g32r502/common/source/: device.c
  group driverlib
    ../../../../../../driverlib/: adc.c as.c can.c cap.c comp.c cortex.c dac.c dbgmcu.c dccomp.c dma.c exti.c flash.c gpio.c hrpwm.c i2c.c interrupt.c lin.c pmbus.c pwm.c qep.c spi.c sysctl.c tmr.c uart.c version.c xbar.c
  group user
    ../../source/: main.c boot_ex2_customBootConfig.c
