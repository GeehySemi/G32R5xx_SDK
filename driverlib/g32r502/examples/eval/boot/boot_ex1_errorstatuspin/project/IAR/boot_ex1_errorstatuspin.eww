<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\boot_ex1_errorstatuspin.ewp</path>
    </project>
    <batchBuild />
</workspace>
