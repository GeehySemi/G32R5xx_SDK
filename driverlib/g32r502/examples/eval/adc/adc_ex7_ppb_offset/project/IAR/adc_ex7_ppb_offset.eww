<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\adc_ex7_ppb_offset.ewp</path>
    </project>
    <batchBuild />
</workspace>
