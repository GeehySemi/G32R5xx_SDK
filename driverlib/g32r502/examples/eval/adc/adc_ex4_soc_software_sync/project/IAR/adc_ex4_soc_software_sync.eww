<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\adc_ex4_soc_software_sync.ewp</path>
    </project>
    <batchBuild />
</workspace>
