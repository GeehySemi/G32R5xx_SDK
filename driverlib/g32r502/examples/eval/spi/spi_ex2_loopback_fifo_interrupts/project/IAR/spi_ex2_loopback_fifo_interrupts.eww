<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\spi_ex2_loopback_fifo_interrupts.ewp</path>
    </project>
    <batchBuild />
</workspace>
