<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\lpm_ex2_idlewake_watchdog.ewp</path>
    </project>
    <batchBuild />
</workspace>
