<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\lpm_ex5_haltwake_gpio.ewp</path>
    </project>
    <batchBuild />
</workspace>
