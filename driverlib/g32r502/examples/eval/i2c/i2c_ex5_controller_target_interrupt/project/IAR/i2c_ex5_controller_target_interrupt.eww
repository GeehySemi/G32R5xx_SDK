<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\i2c_ex5_controller_target_interrupt.ewp</path>
    </project>
    <batchBuild />
</workspace>
