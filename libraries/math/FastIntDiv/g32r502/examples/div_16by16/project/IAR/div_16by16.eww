<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\div_16by16.ewp</path>
    </project>
    <batchBuild />
</workspace>
