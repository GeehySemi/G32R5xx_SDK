# Keil uVision project div_64by64.uvprojx, settings and files
target G32R502 (6240000::V6.24::ARMCLANG)
  device: G32R502MC Geehy
  pack: Geehy.G32R5xx_DFP.1.0.3
  cpu: IRAM(0x00000000,0x00004000) IRAM2(0x20000000,0x00006000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M52") FPU3(SFPU) DSP MVE(INT) CDECP(0x01) PACBTI CLOCK(12000000) ESEL ELITTLE
  output: div_64by64 +hex
  AfterMake: fromelf --text -c -o "$L@L.asm" "#L"
  AfterMake: ..\..\..\..\..\..\..\..\utilities\keil_dbg_tool\keil_dbg_tool -r -a "#L" -d .\r502_dbg.ini
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: __G32R502XX__,__ARM_ARCH_8_1M_MAIN___,__ARM_TARGET_COPROC,__G32R502__
  c misc: -mcpu=cortex-m52+nomve.fp+nofp.dp+cdecp0
  c include: ..\..\..\..\..\..\..\..\device_support\g32r502\common\include;..\..\..\..\..\..\..\..\device_support\common\CMSIS\Core\Include;..\..\..\..\..\..\..\..\device_support\g32r502\common\device\Geehy;..\..\..\..\..\..\..\..\device_support\g32r502\common\device\Geehy\system_eval\include;..\..\..\..\..\..\..\..\device_support\common\device\Geehy\system_eval\include;..\..\..\..\..\..\..\..\device_support\g32r502\headers\include;..\..\..\..\..\..\..\..\driverlib\g32r502\boards_support\eval\include;..\..\..\..\..\..\..\..\driverlib\g32r502\driverlib;..\..\..\..\..\..\..\..\driverlib\g32r502\driverlib\inc;..\..\..\..\include;..\..\..\common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x0 size 0x4000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: .\g32r502xc_itcm_ram_noramvector.sct
  group device
    ../../../../../../../../device_support/g32r502/common/device/Geehy/startup/arm/: startup_g32r502.c
    ../../../../../../../../device_support/g32r502/common/device/Geehy/system_eval/: system_g32r502.c
  group driverlib
    ../../../../../../../../driverlib/g32r502/driverlib/: sysctl.c flash.c
  group mathlib
    ../../../../lib/: g32r502_FastIntDiv_AC6.lib
  group common
    ../../../common/: fastintdiv_examples_main.c fastintdiv_examples_setup.c fastintdiv_examples_ref.c
  group user
    ../../source/: fastintdiv_div_64by64.c
