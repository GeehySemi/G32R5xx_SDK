# IAR project div_64by64.ewp, settings and files
configuration G32R502 (ARM, debug)
  General.OGChipSelectEditMenu: G32R502xC Geehy G32R502xCx7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 6
  ICCARM.CCDefines: __G32R502XX__; __ARM_ARCH_8_1M_MAIN___; __ARM_TARGET_COPROC; __G32R502__
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\..\device_support\g32r502\common\include; ..\..\..\..\..\..\..\..\device_support\common\CMSIS\Core\Include; ..\..\..\..\..\..\..\..\device_support\g32r502\common\device\Geehy; ..\..\..\..\..\..\..\..\device_support\g32r502\common\device\Geehy\system_eval\include; ..\..\..\..\..\..\..\..\device_support\common\device\Geehy\system_eval\include; ..\..\..\..\..\..\..\..\device_support\g32r502\headers\include; ..\..\..\..\..\..\..\..\driverlib\g32r502\boards_support\eval\include; ..\..\..\..\..\..\..\..\driverlib\g32r502\driverlib; ..\..\..\..\..\..\..\..\driverlib\g32r502\driverlib\inc; ..\..\..\..\include; ..\..\..\common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: g32r502xcx7_itcm_ram_noramvector.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\lib\g32r502_FastIntDiv_ICC.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group device
    ../../../../../../../../device_support/g32r502/common/device/Geehy/startup/arm/: startup_g32r502.c
    ../../../../../../../../device_support/g32r502/common/device/Geehy/system_eval/: system_g32r502.c
  group driverlib
    ../../../../../../../../driverlib/g32r502/driverlib/: sysctl.c flash.c
  group common
    ../../../common/: fastintdiv_examples_main.c fastintdiv_examples_setup.c fastintdiv_examples_ref.c
  group user
    ../../source/: fastintdiv_div_64by64.c
