<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\div_32by32.ewp</path>
    </project>
    <batchBuild />
</workspace>
