# Keil uVision project coremark_ex1_core.uvprojx, settings and files
target G32R501_CBUS_FLASH (6220000::V6.22::ARMCLANG)
  device: G32R501DVY:CPU0 Geehy
  pack: Geehy.G32R5xx_DFP.1.0.0
  cpu: IRAM(0x00000000,0x0000C000) IRAM2(0x20000000,0x00004000) IRAM3(0x20100000,0x00002000) IRAM4(0x20200000,0x00002000) IRAM5(0x20300000,0x00008000) IROM(0x08000000,0x000A0000) CPUTYPE("Cortex-M52") FPU3(DFPU) DSP MVE(FP) CDECP(0x01) PACBTI CLOCK(12000000) ESEL ELITTLE
  output: coremark_ex1_core +hex
  AfterMake: ..\..\..\..\..\..\..\utilities\keil_dbg_tool\keil_dbg_tool -r -a "#L" -d .\r501_dbg.ini
  c flags: Optim=2 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: __G32R501XX__,__ARM_ARCH_8_1M_MAIN___,__ARM_TARGET_COPROC,__G32R501__,__CORE_CPU0__,G32R501_EVAL,G32R501_RUN_IN_CBUS_FLASH
  c misc: -mcpu=cortex-m52+cdecp0
  c include: ..\..\include;..\..\..\..\..\common;..\..\..\..\port;..\..\..\..\..\..\..\device_support\common\CMSIS\Core\Include;..\..\..\..\..\..\..\device_support\g32r501\common\device\Geehy;..\..\..\..\..\..\..\device_support\g32r501\common\device\Geehy\system_eval\include;..\..\..\..\..\..\..\device_support\common\device\Geehy\system_eval\include;..\..\..\..\..\..\..\device_support\g32r501\common\include;..\..\..\..\..\..\..\device_support\g32r501\headers\include;..\..\..\..\..\..\..\driverlib\g32r501\boards_support\eval\include;..\..\..\..\..\..\..\driverlib\g32r501\driverlib;..\..\..\..\..\..\..\driverlib\g32r501\driverlib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xa0000
  memory RVCT9: RAM 0x0 size 0xc000
  memory RVCT10: RAM 0x20000000 size 0x4000
  scatter file: .\g32r501dxy_cpu0_cbus_flash.sct
  group Device
    ../../../../../../../device_support/g32r501/common/device/Geehy/startup/arm/: startup_g32r501.c
    ../../../../../../../device_support/g32r501/common/device/Geehy/system_eval/: system_g32r501.c
    ../../../../../../../device_support/g32r501/common/source/: device.c
  group driverlib
    ../../../../../../../driverlib/g32r501/driverlib/: adc.c as.c can.c cap.c comp.c cortex.c dac.c dbgmcu.c dccomp.c dma.c exti.c flash.c gpio.c hrcap.c hrpwm.c i2c.c interrupt.c ipc.c lin.c pmbus.c pwm.c qep.c sdf.c spi.c sysctl.c tmr.c uart.c version.c xbar.c
  group User
    ../../source/: main.c coremark_ex1_core.c board.c
  group CoreMark
    ../../../../../coremark/: core_main.c
    ../../../../../common/: core_list_join.c core_matrix.c core_state.c core_util.c
    ../../../../port/: core_portme.c
target G32R501_ITCM_FLASH (6220000::V6.22::ARMCLANG)
  device: G32R501DVY:CPU0 Geehy
  pack: Geehy.G32R5xx_DFP.1.0.0
  cpu: as above
  output: coremark_ex1_core +hex
  AfterMake: ..\..\..\..\..\..\..\utilities\keil_dbg_tool\keil_dbg_tool -r -a "#L" -d .\r501_dbg_itcm_flash.ini
  c flags: Optim=2 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: __G32R501XX__,__ARM_ARCH_8_1M_MAIN___,__ARM_TARGET_COPROC,__G32R501__,__CORE_CPU0__,G32R501_EVAL,G32R501_RUN_IN_ITCM_FLASH
  c misc: -mcpu=cortex-m52+cdecp0
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xa0000
  memory RVCT9: RAM 0x0 size 0xc000
  memory RVCT10: RAM 0x20000000 size 0x4000
  scatter file: .\g32r501dxy_cpu0_itcm_flash.sct
target G32R501_ITCM_RAM (6220000::V6.22::ARMCLANG)
  device: G32R501DVY:CPU0 Geehy
  pack: Geehy.G32R5xx_DFP.1.0.0
  cpu: as above
  output: coremark_ex1_core +hex
  AfterMake: ..\..\..\..\..\..\..\utilities\keil_dbg_tool\keil_dbg_tool -r -a "#L" -d .\r501_dbg_itcm_ram.ini
  c flags: Optim=2 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: __G32R501XX__,__ARM_ARCH_8_1M_MAIN___,__ARM_TARGET_COPROC,__G32R501__,__CORE_CPU0__,G32R501_EVAL,G32R501_RUN_IN_ITCM_RAM
  c misc: -mcpu=cortex-m52+cdecp0
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xa0000
  memory RVCT9: RAM 0x0 size 0xc000
  memory RVCT10: RAM 0x20000000 size 0x4000
  scatter file: .\g32r501dxy_cpu0_itcm_ram.sct
