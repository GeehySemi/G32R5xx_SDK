# IAR project coremark_ex1_core.ewp, settings and files
configuration G32R501_CBUS_FLASH (ARM, debug)
  General.OGChipSelectEditMenu: G32R501DxY Geehy G32R501DxYx7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 6
  ICCARM.CCDefines: __G32R501XX__; __ARM_ARCH_8_1M_MAIN___; __ARM_TARGET_COPROC; __G32R501__; __CORE_CPU0__; G32R501_EVAL; G32R501_RUN_IN_CBUS_FLASH
  ICCARM.CCIncludePath2: ..\..\include; ..\..\..\..\..\..\..\device_support\common\CMSIS\Core\Include; ..\..\..\..\..\..\..\device_support\g32r501\common\device\Geehy; ..\..\..\..\..\..\..\device_support\g32r501\common\device\Geehy\system_eval\include; ..\..\..\..\..\..\..\device_support\common\device\Geehy\system_eval\include; ..\..\..\..\..\..\..\device_support\g32r501\common\include; ..\..\..\..\..\..\..\device_support\g32r501\headers\include; ..\..\..\..\..\..\..\driverlib\g32r501\boards_support\eval\include; ..\..\..\..\..\..\..\driverlib\g32r501\driverlib; ..\..\..\..\..\..\..\driverlib\g32r501\driverlib\inc; ..\..\..\..\..\common; ..\..\..\..\port
  ICCARM.CCOptLevel: Medium
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: g32r501dxyx7_cpu0_cbus_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration G32R501_ITCM_FLASH (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: __G32R501XX__; __ARM_ARCH_8_1M_MAIN___; __ARM_TARGET_COPROC; __G32R501__; __CORE_CPU0__; G32R501_EVAL; G32R501_RUN_IN_ITCM_FLASH
  ILINK.IlinkIcfFile: g32r501dxyx7_cpu0_itcm_flash.icf
configuration G32R501_ITCM_RAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: __G32R501XX__; __ARM_ARCH_8_1M_MAIN___; __ARM_TARGET_COPROC; __G32R501__; __CORE_CPU0__; G32R501_EVAL; G32R501_RUN_IN_ITCM_RAM
  ILINK.IlinkIcfFile: g32r501dxyx7_cpu0_itcm_ram.icf
  group CoreMark/core
    ../../../../../common/: core_list_join.c core_matrix.c core_state.c core_util.c
  group CoreMark/port
    ../../../../port/: core_portme.c
  group device
    ../../../../../../../device_support/g32r501/common/source/: device.c
    ../../../../../../../device_support/g32r501/common/device/Geehy/startup/arm/: startup_g32r501.c
    ../../../../../../../device_support/g32r501/common/device/Geehy/system_eval/: system_g32r501.c
  group driverlib
    ../../../../../../../driverlib/g32r501/driverlib/: adc.c as.c can.c cap.c comp.c cortex.c dac.c dbgmcu.c dccomp.c dma.c exti.c flash.c gpio.c hrcap.c hrpwm.c i2c.c interrupt.c ipc.c lin.c pmbus.c pwm.c qep.c sdf.c spi.c sysctl.c tmr.c uart.c version.c xbar.c
  group user
    ../../source/: board.c coremark_ex1_core.c main.c
    ../../../../../coremark/: core_main.c
