# Keil uVision project coremark_ex1_core.uvprojx, settings and files
target G32R502_CBUS_FLASH (6240000::V6.24::ARMCLANG)
  device: G32R502MC Geehy
  pack: Geehy.G32R5xx_DFP.1.0.3
  cpu: IRAM(0x00000000,0x00004000) IRAM2(0x20000000,0x00006000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M52") FPU3(SFPU) DSP MVE(INT) CDECP(0x01) PACBTI CLOCK(12000000) ESEL ELITTLE
  output: coremark_ex1_core +hex
  AfterMake: ..\..\..\..\..\..\..\utilities\keil_dbg_tool\keil_dbg_tool -r -a "#L" -d .\r502_dbg.ini
  c flags: Optim=5 v6Lang=5 v6LangP=3 v6Lto=1 wLevel=3
  c define: __G32R502XX__,__ARM_ARCH_8_1M_MAIN___,__ARM_TARGET_COPROC,__G32R502__,G32R502_EVAL,G32R502_RUN_IN_CBUS_FLASH
  c misc: -mcpu=cortex-m52+nomve.fp+nofp.dp+cdecp0 -Omax
  c include: ..\..\include;..\..\..\..\..\..\..\device_support\common\CMSIS\Core\Include;..\..\..\..\..\..\..\device_support\g32r502\common\device\Geehy;..\..\..\..\..\..\..\device_support\g32r502\common\device\Geehy\system_eval\include;..\..\..\..\..\..\..\device_support\common\device\Geehy\system_eval\include;..\..\..\..\..\..\..\device_support\g32r502\common\include;..\..\..\..\..\..\..\device_support\g32r502\headers\include;..\..\..\..\..\..\..\driverlib\g32r502\boards_support\eval\include;..\..\..\..\..\..\..\driverlib\g32r502\driverlib;..\..\..\..\..\..\..\driverlib\g32r502\driverlib\inc;..\..\..\..\..\common;..\..\..\..\port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xa0000
  memory RVCT9: RAM 0x0 size 0xc000
  memory RVCT10: RAM 0x20000000 size 0x4000
  scatter file: .\g32r502xc_cbus_flash.sct
  link misc: -Omax
  group device
    ../../../../../../../device_support/g32r502/common/device/Geehy/system_eval/: system_g32r502.c
    ../../../../../../../device_support/g32r502/common/device/Geehy/startup/arm/: startup_g32r502.c
    ../../../../../../../device_support/g32r502/common/source/: device.c
  group driverlib
    ../../../../../../../driverlib/g32r502/driverlib/: adc.c as.c can.c cap.c comp.c cortex.c dac.c dbgmcu.c dccomp.c dma.c exti.c flash.c gpio.c hrpwm.c i2c.c interrupt.c lin.c pmbus.c pwm.c qep.c spi.c sysctl.c tmr.c uart.c version.c xbar.c
  group user
    ../../source/: main.c coremark_ex1_core.c board.c
    ../../../../../coremark/: core_main.c
  group CoreMark/core
    ../../../../../common/: core_list_join.c core_matrix.c core_state.c core_util.c
  group CoreMark/port
    ../../../../port/: core_portme.c
