# IAR project coremark_ex1_core.ewp, settings and files
configuration G32R502_CBUS_FLASH (ARM, debug)
  General.OGChipSelectEditMenu: G32R502xC Geehy G32R502xCx7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 6
  ICCARM.CCDefines: __G32R502XX__; __ARM_ARCH_8_1M_MAIN___; __ARM_TARGET_COPROC; __G32R502__; G32R502_EVAL; G32R502_RUN_IN_CBUS_FLASH
  ICCARM.CCIncludePath2: ..\..\include; ..\..\..\..\..\..\..\device_support\common\CMSIS\Core\Include; ..\..\..\..\..\..\..\device_support\g32r502\common\device\Geehy; ..\..\..\..\..\..\..\device_support\g32r502\common\device\Geehy\system_eval\include; ..\..\..\..\..\..\..\device_support\common\device\Geehy\system_eval\include; ..\..\..\..\..\..\..\device_support\g32r502\common\include; ..\..\..\..\..\..\..\device_support\g32r502\headers\include; ..\..\..\..\..\..\..\driverlib\g32r502\boards_support\eval\include; ..\..\..\..\..\..\..\driverlib\g32r502\driverlib; ..\..\..\..\..\..\..\driverlib\g32r502\driverlib\inc; ..\..\..\..\..\common; ..\..\..\..\port
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: g32r502xcx7_cbus_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CoreMark/core
    ../../../../../common/: core_list_join.c core_matrix.c core_state.c core_util.c
  group CoreMark/port
    ../../../../port/: core_portme.c
  group device
    ../../../../../../../device_support/g32r502/common/source/: device.c
    ../../../../../../../device_support/g32r502/common/device/Geehy/startup/arm/: startup_g32r502.c
    ../../../../../../../device_support/g32r502/common/device/Geehy/system_eval/: system_g32r502.c
  group driverlib
    ../../../../../../../driverlib/g32r502/driverlib/: adc.c as.c can.c cap.c comp.c cortex.c dac.c dbgmcu.c dccomp.c dma.c exti.c flash.c gpio.c hrpwm.c i2c.c interrupt.c lin.c pmbus.c pwm.c qep.c spi.c sysctl.c tmr.c uart.c version.c xbar.c
  group user
    ../../source/: board.c coremark_ex1_core.c main.c
    ../../../../../coremark/: core_main.c
