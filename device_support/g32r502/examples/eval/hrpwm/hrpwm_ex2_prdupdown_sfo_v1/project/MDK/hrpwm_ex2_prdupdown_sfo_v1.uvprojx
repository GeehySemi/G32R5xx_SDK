# Keil uVision project hrpwm_ex2_prdupdown_sfo_v1.uvprojx, settings and files
target G32R502 (6240000::V6.24::ARMCLANG)
  device: G32R502MC Geehy
  pack: Geehy.G32R5xx_DFP.1.0.3
  cpu: IRAM(0x00000000,0x00004000) IRAM2(0x20000000,0x00006000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M52") FPU3(SFPU) DSP MVE(INT) CDECP(0x01) PACBTI CLOCK(12000000) ESEL ELITTLE
  output: hrpwm_ex2_prdupdown_sfo_v1 +hex
  AfterMake: ..\..\..\..\..\..\..\..\utilities\keil_dbg_tool\keil_dbg_tool -r -a "#L" -d .\r502_dbg.ini
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: __G32R502__,__ARM_ARCH_8_1M_MAIN___,__ARM_TARGET_COPROC
  c misc: -mcpu=cortex-m52+nomve.fp+nofp.dp+cdecp0
  c include: ..\..\..\..\..\..\headers\include;..\..\..\..\..\..\..\common\CMSIS\Core\Include;..\..\..\..\..\..\common\device\Geehy;..\..\..\..\..\..\common\device\Geehy\system_eval\include;..\..\..\..\..\..\..\common\device\Geehy\system_eval\include;..\..\..\..\..\..\common\include;..\..\..\..\..\..\..\..\driverlib\g32r502\driverlib;..\..\..\..\..\..\..\..\driverlib\g32r502\driverlib\inc;..\..\..\..\..\..\..\..\libraries\calibration\hrpwm\g32r502\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xa0000
  memory RVCT9: RAM 0x0 size 0xc000
  memory RVCT10: RAM 0x20000000 size 0x4000
  scatter file: .\g32r502xc_cbus_flash.sct
  group device
    ../../../../../../common/device/Geehy/startup/arm/: startup_g32r502.c
    ../../../../../../common/device/Geehy/system_eval/: system_g32r502.c
  group device_support
    ../../../../../../common/: g32r502_globalvariabledefs.c
    ../../../../../../common/source/: g32r502_adc.c g32r502_dma.c g32r502_exti.c g32r502_gpio.c g32r502_spi.c g32r502_sysctrl.c g32r502_tmrs.c
  group driverlib
    ../../../../../../../../driverlib/g32r502/driverlib/: interrupt.c
  group user
    ../../source/: main.c hrpwm_ex2_prdupdown_sfo_v1.c
  group library
    ../../../../../../../../libraries/calibration/hrpwm/g32r502/lib/: SFO_AC6.lib
