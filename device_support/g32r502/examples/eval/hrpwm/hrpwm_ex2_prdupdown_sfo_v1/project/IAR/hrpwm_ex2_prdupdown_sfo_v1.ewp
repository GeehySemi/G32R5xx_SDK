# IAR project hrpwm_ex2_prdupdown_sfo_v1.ewp, settings and files
configuration G32R502 (ARM, debug)
  General.OGChipSelectEditMenu: G32R502xC Geehy G32R502xCx7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 6
  ICCARM.CCDefines: __G32R502__; __ARM_ARCH_8_1M_MAIN___; __ARM_TARGET_COPROC
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\headers\include; ..\..\..\..\..\..\..\common\CMSIS\Core\Include; ..\..\..\..\..\..\common\device\Geehy; ..\..\..\..\..\..\common\device\Geehy\system_eval\include; ..\..\..\..\..\..\..\common\device\Geehy\system_eval\include; ..\..\..\..\..\..\common\include; ..\..\..\..\..\..\..\..\driverlib\g32r502\driverlib; ..\..\..\..\..\..\..\..\driverlib\g32r502\driverlib\inc; ..\..\..\..\..\..\..\..\libraries\calibration\hrpwm\g32r502\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: g32r502xcx7_cbus_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\..\..\libraries\calibration\hrpwm\g32r502\lib\SFO_ICC.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group device
    ../../../../../../common/device/Geehy/startup/arm/: startup_g32r502.c
    ../../../../../../common/device/Geehy/system_eval/: system_g32r502.c
  group device_support
    ../../../../../../common/: g32r502_globalvariabledefs.c
    ../../../../../../common/source/: g32r502_adc.c g32r502_dma.c g32r502_exti.c g32r502_gpio.c g32r502_spi.c g32r502_sysctrl.c g32r502_tmrs.c
  group driverlib
    ../../../../../../../../driverlib/g32r502/driverlib/: interrupt.c
  group user
    ../../source/: main.c hrpwm_ex2_prdupdown_sfo_v1.c
