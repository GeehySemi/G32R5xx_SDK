<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\dac_ex1_enable.ewp</path>
    </project>
    <batchBuild />
</workspace>
