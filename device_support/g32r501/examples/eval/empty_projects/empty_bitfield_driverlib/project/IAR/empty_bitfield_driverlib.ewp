# IAR project empty_bitfield_driverlib.ewp, settings and files
configuration G32R501 (ARM, debug)
  General.OGChipSelectEditMenu: G32R501DxY Geehy G32R501DxYx7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: __G32R501XX__; __G32R501__; __ARM_ARCH_8_1M_MAIN___; __ARM_TARGET_COPROC; __CORE_CPU0__; G32R501_EVAL
  ICCARM.IExtraOptions: --cdecp=0
  ICCARM.CCIncludePath2: ..\..\include; ..\..\..\..\..\..\headers\include; ..\..\..\..\..\..\..\common\CMSIS\Core\Include; ..\..\..\..\..\..\common\device\Geehy; ..\..\..\..\..\..\common\device\Geehy\system_eval\include; ..\..\..\..\..\..\..\common\device\Geehy\system_eval\include; ..\..\..\..\..\..\common\include; ..\..\..\..\..\..\..\..\driverlib\g32r501\driverlib; ..\..\..\..\..\..\..\..\driverlib\g32r501\driverlib\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: g32r501dxyx7_cpu0_cbus_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group device
    ../../../../../../common/device/Geehy/startup/arm/: startup_g32r501.c
    ../../../../../../common/device/Geehy/system_eval/: system_g32r501.c
    ../../../../../../common/source/: device.c
  group device_support
    ../../../../../../common/source/: g32r501_adc.c g32r501_dma.c g32r501_exti.c g32r501_gpio.c g32r501_spi.c g32r501_sysctrl.c g32r501_tmrs.c
    ../../../../../../common/: g32r501_globalvariabledefs.c
  group driverlib
    ../../../../../../../../driverlib/g32r501/driverlib/: adc.c as.c can.c cap.c comp.c cortex.c dac.c dbgmcu.c dccomp.c dma.c exti.c flash.c gpio.c hrcap.c hrpwm.c i2c.c interrupt.c ipc.c lin.c pmbus.c pwm.c qep.c sdf.c spi.c sysctl.c tmr.c uart.c version.c xbar.c
  group user
    ../../source/: empty_bitfield_driverlib_main.c main.c
