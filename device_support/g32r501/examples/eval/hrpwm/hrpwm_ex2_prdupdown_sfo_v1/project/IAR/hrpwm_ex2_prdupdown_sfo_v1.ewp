# IAR project hrpwm_ex2_prdupdown_sfo_v1.ewp, settings and files
configuration G32R501 (ARM, debug)
  General.OGChipSelectEditMenu: G32R501DxY Geehy G32R501DxYx7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: __G32R501__; __ARM_ARCH_8_1M_MAIN___; __ARM_TARGET_COPROC; __CORE_CPU0__; G32R501_EVAL
  ICCARM.IExtraOptions: --cdecp=0
  ICCARM.CCIncludePath2: ..\..\include; ..\..\..\..\..\..\headers\include; ..\..\..\..\..\..\..\common\CMSIS\Core\Include; ..\..\..\..\..\..\common\device\Geehy; ..\..\..\..\..\..\common\device\Geehy\system_eval\include; ..\..\..\..\..\..\..\common\device\Geehy\system_eval\include; ..\..\..\..\..\..\common\include; ..\..\..\..\..\..\..\..\driverlib\g32r501\driverlib; ..\..\..\..\..\..\..\..\driverlib\g32r501\driverlib\inc; ..\..\..\..\..\..\..\..\libraries\calibration\hrpwm\g32r501\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: g32r501dxyx7_cpu0_cbus_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\..\..\libraries\calibration\hrpwm\g32r501\lib\SFO_ICC.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group device
    ../../../../../../common/device/Geehy/startup/arm/: startup_g32r501.c
    ../../../../../../common/device/Geehy/system_eval/: system_g32r501.c
  group device_support
    ../../../../../../common/source/: g32r501_adc.c g32r501_dma.c g32r501_exti.c g32r501_gpio.c g32r501_spi.c g32r501_sysctrl.c g32r501_tmrs.c
    ../../../../../../common/: g32r501_globalvariabledefs.c
  group driverlib
    ../../../../../../../../driverlib/g32r501/driverlib/: interrupt.c
  group user
    ../../source/: hrpwm_ex2_prdupdown_sfo_v1.c main.c
