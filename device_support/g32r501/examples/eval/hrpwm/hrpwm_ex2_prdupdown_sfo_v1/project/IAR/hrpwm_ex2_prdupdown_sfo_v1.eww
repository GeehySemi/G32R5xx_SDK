<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\hrpwm_ex2_prdupdown_sfo_v1.ewp</path>
    </project>
    <batchBuild />
</workspace>
