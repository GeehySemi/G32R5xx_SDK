<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\uart_ex1_echoback.ewp</path>
    </project>
    <batchBuild />
</workspace>
